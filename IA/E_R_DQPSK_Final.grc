<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>E_R_DQPSK_1</value></param>
<param><key>author</key><value>Hervé BOEGLEN et Laurent MURA</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Transmission DQPSK</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>15</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Rapport SIgnal sur Bruit</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.06</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Reglage PLL</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Decalage frequence</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.8</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_sin</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Frequence son emission</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>4000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_canal</value></param>
<param><key>value</key><value>1.5</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Gain canal</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.02</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>qpsk</value></param>
<param><key>const_points</key><value>[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(4), 0.35, 11*4*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_USRP</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>[1.0 + 0.0j, ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Volume reception</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq_sin</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>hw:0,1</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>type</key><value>float</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>64</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>4</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/laurent/Documents/MPSK_USRP/son1_8b_441_stereo.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>(10**(-SNR/10.0))*np.sqrt(samp_per_sym)</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>gain_canal</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>qpsk</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>qpsk</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>samples_per_symbol</key><value>4</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>alpha</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>4</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>0.35</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from cmath import exp, pi; from random import randint; import numpy as np;</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>Constellation avant AGC</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>Constellation apres Costas Lopp</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate*4</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>FFT avant AGC</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Signal demodule</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate*4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
